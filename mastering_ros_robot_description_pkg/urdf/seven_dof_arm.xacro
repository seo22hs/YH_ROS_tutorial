Commit message: Day7 초기 코드 작성

File: mastering_ros_robot_description_pkg/urdf/seven_dof_arm.xacro (robot description, xacro)
@@ -91,5 +91,5 @@
 	       <box size="1 1 0.02" />
       </geometry>
-      </collision>>
+      </collision>
   </link>
   <gazebo reference="bottom_link">
